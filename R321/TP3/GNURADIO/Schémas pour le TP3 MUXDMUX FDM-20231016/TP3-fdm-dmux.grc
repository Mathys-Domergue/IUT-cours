options:
  parameters:
    author: Philippe PUJAS
    generate_options: qt_gui
    id: MUX_DMUX_FDM
    output_language: python
    title: Multiplexeur démultiplexeur FDM
  states: {}

blocks:
- name: BP
  id: variable
  parameters:
    value: '18000'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: canal_sel
  id: variable_qtgui_dial_control
  parameters:
    label: Canal
    maximum: '5'
    minimum: '0'
    showvalue: 'True'
    type: real
    value: '0'
  states: {}
- name: ch0
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: chsp
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: num_canal_A
  id: variable
  parameters:
    value: '0'
  states: {}
- name: num_canal_B
  id: variable
  parameters:
    value: '3'
  states: {}
- name: num_canal_C
  id: variable
  parameters:
    value: '3.4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1920000/2
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: ch0+num_canal_A*chsp
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: ch0+num_canal_B*chsp
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: ch0+num_canal_C*chsp
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: canal_sel*chsp+ch0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: canal_sel*chsp+ch0+BP/2
    low_cutoff_freq: canal_sel*chsp+ch0-BP/2
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/lucky/Desktop/IUT-cours/R321/TP3/GNURADIO/Fichiers Wav échantillonnées à 960 kHz pour le TP3-20231016/01-960k.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/lucky/Desktop/IUT-cours/R321/TP3/GNURADIO/12-large-960k.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/lucky/Desktop/IUT-cours/R321/TP3/GNURADIO/Fichiers Wav échantillonnées à 960 kHz pour le TP3-20231016/09-960k.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: BP/2
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: Multiplex des programmes A,B,C
    type: float
    wintype: window.WIN_FLATTOP
    ymin: '-150'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: Programme démultiplexé
    type: float
    wintype: window.WIN_FLATTOP
    ymin: '-150'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: Programme A
    label2: Programme B
    label3: Programme C
    nconnections: '3'
    type: float
    wintype: window.WIN_FLATTOP
    ymin: '-150'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/audio_rate)
    interp: '1'
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '1']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_add_xx_0, '0', band_pass_filter_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_xx_0, '1']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_wavfile_source_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_wavfile_source_0_0, '0', qtgui_freq_sink_x_0_1, '1']
- [blocks_wavfile_source_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_wavfile_source_0_0_0, '0', qtgui_freq_sink_x_0_1, '2']
- [low_pass_filter_0_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0_0_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
